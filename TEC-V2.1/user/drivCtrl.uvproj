# Keil uVision project drivCtrl.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051K8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: drivCtrl +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\inc;..\stm32f0;..\lib;..\drive;..\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f0xx.s
  group inc
    ../inc/: system_stm32f0xx.c stm32f0xx_iwdg.h stm32f0xx_adc.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group user
    ./: main.c
  group lib
    ../lib/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_it.c stm32f0xx_dac.c stm32f0xx_dma.c stm32f0xx_tim.c stm32f0xx_adc.c stm32f0xx_syscfg.c stm32f0xx_exti.c stm32f0xx_iwdg.c
    ../../Green Final-RedDriveCtrlV3.3/lib/: stm32f0xx_flash.c
  group drive
    ../drive/: enable.c dac.c state.c fault.c PWM.c dir.c rdctrl.c usart.c eeprom_emulation.c protocol.c adc.c converter.c delay.c exit.c iwdg.c systick.c
